# Keil uVision project FFT.uvprojx, settings and files
target FFT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\STM32F10x_DSP_Lib\inc;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\FFT;..\HARDWARE\usart3;..\HARDWARE\HC05;..\HARDWARE\AD9854;..\HARDWARE\AD9851;..\HARDWARE\AD9851_2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/FFT/: fft.c
    ../HARDWARE/AD9854/: AD9854.c
    ../HARDWARE/AD9851/: 9851.c
    ../HARDWARE/AD9851_2/: 9851_2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_dma.c
  group README
    ../: README.TXT
  group DSP LIB
    ../STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
    ../STM32F10x_DSP_Lib/src/asm/arm/: cr4_fft_1024_stm32.s
